# Keil uVision project soc.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CMSDK_CM3 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: soc
  AfterMake: fromelf -cvf .\soc.axf --vhx --32x1 -o image.hex
  AfterMake: fromelf -cvf .\soc.axf -o image.txt
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group New Group
    ../Software/no_camera_new/: acc.c camera.c camera_initial_reg_file.h core_cm3.h core_cmFunc.h core_cmInstr.h CortexM3.h dma.c gpio.c handler.c keyboard.c lcd.c main.c resizer.c Retarget.c startup_CM3DS.s system_init.c systick.c test_acc.c timer.c uart.c
target Target 2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CMSDK_CM3 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: as above
  output: soc
  AfterMake: fromelf -cvf .\soc.axf --vhx --32x1 -o image.hex
  AfterMake: fromelf -cvf .\soc.axf -o image.txt
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
